# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\UCOSII\CORE;..\UCOSII\CONFIG;..\UCOSII\PORT;..\MALLOC;..\HARDWARE\WK2124;..\HARDWARE\RS485;..\HARDWARE\DM9000;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP;..\LWIP\arch;..\LWIP\lwip_app\lwip_comm;..\HARDWARE\SDIO;..\FATFS;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\W25QXX;..\HARDWARE\RTC;..\4G;..\HARDWARE\ST16C554-RS232;..\HARDWARE\SRAM;..\HARDWARE\IIC;..\HARDWARE\SD3078;..\HARDWARE\ADC;..\HARDWARE\PWCTROL;..\HARDWARE\ATK-S1218;..\USMART;..\FTP;..\HARDWARE\ST16C554-RS232;..\HARDWARE\LOW-Power;..\HARDWARE\ATK-HC05;..\HARDWARE\Water-Rainfall-Sensor;..\PROTOCOL;..\BLUETOOTH;..\COMMON;..\THREAD;..\MEMORY;..\4G\DMAUSART2;..\HARDWARE\RS232;..\HARDWARE\USB\CONFIG;..\HARDWARE\USB\STM32_USB-FS-Device_Driver\inc;..\HARDWARE\IWDG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c version.txt
  group THREAD
    ../THREAD/: thread.c
  group COMMON
    ../COMMON/: common.c
  group HARDWARE
    ../HARDWARE/WK2124/: wk2124.c spi.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/DM9000/: dm9000.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ST16C554-RS232/: st16c554.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/SD3078/: sd3078rtc.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/PWCTROL/: pwctrl.c
    ../HARDWARE/ATK-HC05/: hco5.c
    ../HARDWARE/ATK-S1218/: gps.c
    ../HARDWARE/LOW-Power/: wkup.c
    ../HARDWARE/Water-Rainfall-Sensor/: sensor_water.c
    ../HARDWARE/RS232/: rs232.c
    ../HARDWARE/IWDG/: iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_wwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group USB_CORE
    ../HARDWARE/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../HARDWARE/USB/CONFIG/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group MALLOC
    ../MALLOC/: malloc.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/: picture.c
  group 4G/FTPD
    ../4G/: 4g.c short_letter.c
    ../FTP/: ftpd.c
    ../4G/DMAUSART2/: dmausart.c
  group BLUETOOTH
    ../BLUETOOTH/: bluetooth.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group PROTOCOL
    ../PROTOCOL/: protocol.c
  group MEMORY
    ../MEMORY/: memory_my.c
